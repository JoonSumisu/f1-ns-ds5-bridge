## firmware/s3-ds5/sdkconfig.defaults
```kconfig
CONFIG_ESPTOOLPY_FLASHSIZE_16MB=y
CONFIG_COMPILER_OPTIMIZATION_PERF=y
CONFIG_TINYUSB_HID_COUNT=1
CONFIG_FREERTOS_HZ=1000
```
